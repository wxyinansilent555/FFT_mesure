# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\user;..\stm32f103-FWLib\inc;..\system\delay;..\system\sys;..\system\usart;..\my\led;..\my\key;..\my\LCD;..\my\ADC;..\my\TIMER;..\my\DMA;..\stm32f103-FWLib\dsp;..\my\FFT
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLib
    ../stm32f103-FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group my
    ../my/led/: led.c
    ../my/key/: key.c
    ../my/LCD/: lcd.c
    ../my/ADC/: adc.c
    ../my/TIMER/: timer.c
    ../my/DMA/: dma.c
    ../my/FFT/: fft_calculate.c
  group dsp
    ../stm32f103-FWLib/dsp/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
